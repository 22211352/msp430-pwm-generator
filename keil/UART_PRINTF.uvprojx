# Keil uVision project UART_PRINTF.uvprojx, settings and files
target UART_PRINTF (6210000::V6.21::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ..\Core\inc;..\Driver;..\Driver\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Core
    ../Core/src/: main.c ti_msp_dl_config.c key.c oled.c CLKUpdate.h
    ./: startup_mspm0l1306_uvision.s
    ../: project.syscfg
    ../Core/inc/: ti_msp_dl_config.h oledfont.h oled.h
  group Driver
    ../Driver/ti/driverlib/: dl_adc12.c dl_aes.c dl_common.c dl_crc.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../Driver/ti/driverlib/m0p/: dl_interrupt.c
    ../Driver/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0l11xx_l13xx.c
